// A port of scipy 1.18.1's xsf (subprojects/xsf/include/xsf/cephes/:
// igam.h, igami.h, gamma.h, lanczos.h, unity.h, zeta.h, ndtr.h, polevl.h,
// trig.h, igam_asymp_coeff.h, const.h) as far as gammaincc/gammainccinv
// reach. See special.hpp for what is kept and why.
//
// The statements are xsf's own, in its order, with its constants; only
// the error reporting (xsf's set_error, which scipy keeps silent by
// default) is dropped. Do not "simplify" an expression here: the point of
// the port is that each rounding happens where scipy's does.
//
// Licences of the code this is translated from:
//
//   Cephes Math Library Release 2.0 / 2.3 / 2.8,
//   Copyright 1984, 1985, 1987, 1995, 2000 by Stephen L. Moshier,
//   distributed with SciPy under SciPy's BSD-3-Clause licence.
//
//   SciPy (the C++ translation and the 2016 changes to igam.c), Copyright
//   (c) 2001-2002 Enthought, Inc. 2003, SciPy Developers. BSD-3-Clause:
//   redistribution in source form must retain this notice, the list of
//   conditions and the disclaimer of SciPy's LICENSE.txt.
//
//   Lanczos coefficients (lanczos.h), (C) Copyright John Maddock 2006.
//   Use, modification and distribution are subject to the Boost Software
//   License, Version 1.0 (https://www.boost.org/LICENSE_1_0.txt).

#include "math/special.hpp"

#include <cmath>
#include <cstddef>
#include <cstdint>
#include <limits>

namespace sstvae::math {
namespace {

// --- const.h ----------------------------------------------------------------

constexpr double MACHEP = 1.1102230246251565404236316680908203125E-16;  // 2**-53
constexpr double MAXLOG = 7.097827128933839730962063185871E2;           // log(DBL_MAX)
constexpr double SQRT2PI = 2.506628274631000502415765284811045253007;   // sqrt(2*pi)
constexpr double LOGPI = 1.144729885849400174143427351353058711647;     // log(pi)
constexpr double MAXGAM = 171.624376956302725;
constexpr double SCIPY_EULER = 0.577215664901532860606512090082402431;
constexpr std::uint64_t MAXITER = 500;

// config.h
constexpr double XSF_PI = 3.14159265358979323846;
constexpr double XSF_SQRT2 = 1.41421356237309504880;
constexpr double XSF_SQRT1_2 = 0.707106781186547524401;

constexpr double NaN = std::numeric_limits<double>::quiet_NaN();
constexpr double INF = std::numeric_limits<double>::infinity();

// --- polevl.h ---------------------------------------------------------------

double polevl(double x, const double coef[], int N) {
    const double* p = coef;
    double ans = *p++;
    int i = N;
    do {
        ans = ans * x + *p++;
    } while (--i);
    return ans;
}

double p1evl(double x, const double coef[], int N) {
    const double* p = coef;
    double ans = x + *p++;
    int i = N - 1;
    do
        ans = ans * x + *p++;
    while (--i);
    return ans;
}

double ratevl(double x, const double num[], int M, const double denom[], int N) {
    int i, dir;
    double y, num_ans, denom_ans;
    double absx = std::abs(x);
    const double* p;

    if (absx > 1) {
        dir = -1;
        p = num + M;
        y = 1 / x;
    } else {
        dir = 1;
        p = num;
        y = x;
    }
    num_ans = *p;
    p += dir;
    for (i = 1; i <= M; i++) {
        num_ans = num_ans * y + *p;
        p += dir;
    }
    if (absx > 1) {
        p = denom + N;
    } else {
        p = denom;
    }
    denom_ans = *p;
    p += dir;
    for (i = 1; i <= N; i++) {
        denom_ans = denom_ans * y + *p;
        p += dir;
    }
    if (absx > 1) {
        i = M - N;
        return std::pow(x, i) * num_ans / denom_ans;
    }
    return num_ans / denom_ans;
}

// --- trig.h -----------------------------------------------------------------

double sinpi(double x) {
    double s = 1.0;
    if (std::signbit(x)) {
        x = -x;
        s = -1.0;
    }
    double r = std::fmod(x, 2.0);
    if (r < 0.5) return s * std::sin(XSF_PI * r);
    if (r > 1.5) return s * std::sin(XSF_PI * (r - 2.0));
    return -s * std::sin(XSF_PI * (r - 1.0));
}

// --- gamma.h ----------------------------------------------------------------

constexpr double gamma_P[] = {1.60119522476751861407E-4, 1.19135147006586384913E-3, 1.04213797561761569935E-2,
                              4.76367800457137231464E-2, 2.07448227648435975150E-1, 4.94214826801497100753E-1,
                              9.99999999999999996796E-1};
constexpr double gamma_Q[] = {-2.31581873324120129819E-5, 5.39605580493303397842E-4, -4.45641913851797240494E-3,
                              1.18139785222060435552E-2,  3.58236398605498653373E-2, -2.34591795718243348568E-1,
                              7.14304917030273074085E-2,  1.00000000000000000320E0};
constexpr double gamma_STIR[5] = {
    7.87311395793093628397E-4, -2.29549961613378126380E-4, -2.68132617805781232825E-3,
    3.47222221605458667310E-3, 8.33333333333482257126E-2,
};
constexpr double MAXSTIR = 143.01608;

double stirf(double x) {
    double y, w, v;
    if (x >= MAXGAM) return INF;
    w = 1.0 / x;
    w = 1.0 + w * polevl(w, gamma_STIR, 4);
    y = std::exp(x);
    if (x > MAXSTIR) {
        v = std::pow(x, 0.5 * x - 0.25);
        y = v * (v / y);
    } else {
        y = std::pow(x, x - 0.5) / y;
    }
    y = SQRT2PI * y * w;
    return y;
}

double Gamma(double x) {
    double p, q, z;
    int i;
    int sgngam = 1;

    if (!std::isfinite(x)) {
        if (x > 0) return x;
        return NaN;
    }
    if (x == 0) return std::copysign(INF, x);

    q = std::abs(x);
    if (q > 33.0) {
        if (x < 0.0) {
            p = std::floor(q);
            if (p == q) return NaN;
            i = static_cast<int>(p);
            if ((i & 1) == 0) sgngam = -1;
            z = q - p;
            if (z > 0.5) {
                p += 1.0;
                z = q - p;
            }
            z = q * sinpi(z);
            if (z == 0.0) return sgngam * INF;
            z = std::abs(z);
            z = XSF_PI / (z * stirf(q));
        } else {
            z = stirf(x);
        }
        return sgngam * z;
    }

    z = 1.0;
    while (x >= 3.0) {
        x -= 1.0;
        z *= x;
    }
    while (x < 0.0) {
        if (x > -1.E-9) goto small;
        z /= x;
        x += 1.0;
    }
    while (x < 2.0) {
        if (x < 1.e-9) goto small;
        z /= x;
        x += 1.0;
    }
    if (x == 2.0) return z;
    x -= 2.0;
    p = polevl(x, gamma_P, 6);
    q = polevl(x, gamma_Q, 7);
    return z * p / q;

small:
    if (x == 0.0) return NaN;
    return z / ((1.0 + 0.5772156649015329 * x) * x);
}

constexpr double gamma_A[] = {8.11614167470508450300E-4, -5.95061904284301438324E-4, 7.93650340457716943945E-4,
                              -2.77777777730099687205E-3, 8.33333333333331927722E-2};
constexpr double gamma_B[] = {-1.37825152569120859100E3, -3.88016315134637840924E4, -3.31612992738871184744E5,
                              -1.16237097492762307383E6, -1.72173700820839662146E6, -8.53555664245765465627E5};
constexpr double gamma_C[] = {-3.51815701436523470549E2, -1.70642106651881159223E4, -2.20528590553854454839E5,
                              -1.13933444367982507207E6, -2.53252307177582951285E6, -2.01889141433532773231E6};
constexpr double LS2PI = 0.91893853320467274178;
constexpr double MAXLGM = 2.556348e305;

double lgam_large_x(double x) {
    double q = (x - 0.5) * std::log(x) - x + LS2PI;
    if (x > 1.0e8) return q;
    double p = 1.0 / (x * x);
    p = ((7.9365079365079365079365e-4 * p - 2.7777777777777777777778e-3) * p + 0.0833333333333333333333) / x;
    return q + p;
}

double lgam_sgn(double x, int* sign) {
    double p, q, u, w, z;
    int i;

    *sign = 1;
    if (!std::isfinite(x)) return x;

    if (x < -34.0) {
        q = -x;
        w = lgam_sgn(q, sign);
        p = std::floor(q);
        if (p == q) {
        lgsing:
            return INF;
        }
        i = static_cast<int>(p);
        if ((i & 1) == 0) {
            *sign = -1;
        } else {
            *sign = 1;
        }
        z = q - p;
        if (z > 0.5) {
            p += 1.0;
            z = p - q;
        }
        z = q * sinpi(z);
        if (z == 0.0) goto lgsing;
        z = LOGPI - std::log(z) - w;
        return z;
    }

    if (x < 13.0) {
        z = 1.0;
        p = 0.0;
        u = x;
        while (u >= 3.0) {
            p -= 1.0;
            u = x + p;
            z *= u;
        }
        while (u < 2.0) {
            if (u == 0.0) goto lgsing;
            z /= u;
            p += 1.0;
            u = x + p;
        }
        if (z < 0.0) {
            *sign = -1;
            z = -z;
        } else {
            *sign = 1;
        }
        if (u == 2.0) return std::log(z);
        p -= 2.0;
        x = x + p;
        p = x * polevl(x, gamma_B, 5) / p1evl(x, gamma_C, 6);
        return std::log(z) + p;
    }

    if (x > MAXLGM) return *sign * INF;
    if (x >= 1000.0) return lgam_large_x(x);

    q = (x - 0.5) * std::log(x) - x + LS2PI;
    p = 1.0 / (x * x);
    return q + polevl(p, gamma_A, 4) / x;
}

double lgam_(double x) {
    int sign;
    return lgam_sgn(x, &sign);
}

// --- lanczos.h --------------------------------------------------------------

constexpr double lanczos_sum_expg_scaled_num[] = {
    0.006061842346248906525783753964555936883222, 0.5098416655656676188125178644804694509993,
    19.51992788247617482847860966235652136208,    449.9445569063168119446858607650988409623,
    6955.999602515376140356310115515198987526,    75999.29304014542649875303443598909137092,
    601859.6171681098786670226533699352302507,    3481712.15498064590882071018964774556468,
    14605578.08768506808414169982791359218571,    43338889.32467613834773723740590533316085,
    86363131.28813859145546927288977868422342,    103794043.1163445451906271053616070238554,
    56906521.91347156388090791033559122686859};
constexpr double lanczos_sum_expg_scaled_denom[] = {1,         66,       1925,     32670,     357423,
                                                    2637558,   13339535, 45995730, 105258076, 150917976,
                                                    120543840, 39916800, 0};
constexpr double lanczos_g = 6.024680040776729583740234375;

double lanczos_sum_expg_scaled(double x) {
    return ratevl(x, lanczos_sum_expg_scaled_num, 12, lanczos_sum_expg_scaled_denom, 12);
}

// --- zeta.h -----------------------------------------------------------------

constexpr double zeta_A[] = {12.0,
                             -720.0,
                             30240.0,
                             -1209600.0,
                             47900160.0,
                             -1.8924375803183791606e9,
                             7.47242496e10,
                             -2.950130727918164224e12,
                             1.1646782814350067249e14,
                             -4.5979787224074726105e15,
                             1.8152105401943546773e17,
                             -7.1661652561756670113e18};

double zeta_(double x, double q) {
    int i;
    double a, b, k, s, t, w;

    if (x == 1.0) goto retinf;
    if (x < 1.0) {
    domerr:
        return NaN;
    }
    if (q <= 0.0) {
        if (q == std::floor(q)) {
        retinf:
            return INF;
        }
        if (x != std::floor(x)) goto domerr;
    }
    if (q > 1e8) {
        return (1 / (x - 1) + 1 / (2 * q)) * std::pow(q, 1 - x);
    }

    s = std::pow(q, -x);
    a = q;
    i = 0;
    b = 0.0;
    while ((i < 9) || (a <= 9.0)) {
        i += 1;
        a += 1.0;
        b = std::pow(a, -x);
        s += b;
        if (std::abs(b / s) < MACHEP) goto done;
    }

    w = a;
    s += b * w / (x - 1.0);
    s -= 0.5 * b;
    a = 1.0;
    k = 0.0;
    for (i = 0; i < 12; i++) {
        a *= x + k;
        b /= w;
        t = a * b / zeta_A[i];
        s = s + t;
        t = std::abs(t / s);
        if (t < MACHEP) goto done;
        k += 1.0;
        a *= x + k;
        b /= w;
        k += 1.0;
    }
done:
    return s;
}

// --- unity.h ----------------------------------------------------------------

constexpr double unity_LP[] = {
    4.5270000862445199635215E-5, 4.9854102823193375972212E-1, 6.5787325942061044846969E0,
    2.9911919328553073277375E1,  6.0949667980987787057556E1,  5.7112963590585538103336E1,
    2.0039553499201281259648E1,
};
constexpr double unity_LQ[] = {
    1.5062909083469192043167E1, 8.3047565967967209469434E1, 2.2176239823732856465394E2,
    3.0909872225312059774938E2, 2.1642788614495947685003E2, 6.0118660497603843919306E1,
};

double cephes_log1p(double x) {
    double z = 1.0 + x;
    if ((z < XSF_SQRT1_2) || (z > XSF_SQRT2)) return std::log(z);
    z = x * x;
    z = -0.5 * z + x * (z * polevl(x, unity_LP, 6) / p1evl(x, unity_LQ, 6));
    return x + z;
}

double log1pmx(double x) {
    if (std::abs(x) < 0.5) {
        std::uint64_t n;
        double xfac = x;
        double term;
        double res = 0;
        for (n = 2; n < MAXITER; n++) {
            xfac *= -x;
            term = xfac / static_cast<double>(n);
            res += term;
            if (std::abs(term) < MACHEP * std::abs(res)) break;
        }
        return res;
    }
    return cephes_log1p(x) - x;
}

constexpr double unity_EP[3] = {
    1.2617719307481059087798E-4,
    3.0299440770744196129956E-2,
    9.9999999999999999991025E-1,
};
constexpr double unity_EQ[4] = {
    3.0019850513866445504159E-6,
    2.5244834034968410419224E-3,
    2.2726554820815502876593E-1,
    2.0000000000000000000897E0,
};

double cephes_expm1(double x) {
    double r, xx;
    if (!std::isfinite(x)) {
        if (std::isnan(x)) return x;
        if (x > 0) return x;
        return -1.0;
    }
    if ((x < -0.5) || (x > 0.5)) return std::exp(x) - 1.0;
    xx = x * x;
    r = x * polevl(xx, unity_EP, 2);
    r = r / (polevl(xx, unity_EQ, 3) - r);
    return r + r;
}

double lgam1p_taylor(double x) {
    int n;
    double xfac, coeff, res;
    if (x == 0) return 0;
    res = -SCIPY_EULER * x;
    xfac = -x;
    for (n = 2; n < 42; n++) {
        xfac *= -x;
        coeff = zeta_(n, 1) * xfac / n;
        res += coeff;
        if (std::abs(coeff) < MACHEP * std::abs(res)) break;
    }
    return res;
}

double lgam1p(double x) {
    if (std::abs(x) <= 0.5) return lgam1p_taylor(x);
    if (std::abs(x - 1) < 0.5) return std::log(x) + lgam1p_taylor(x - 1);
    return lgam_(x + 1);
}

// --- ndtr.h (erf, erfc) -----------------------------------------------------

constexpr double ndtr_P[] = {2.46196981473530512524E-10, 5.64189564831068821977E-1, 7.46321056442269912687E0,
                             4.86371970985681366614E1,   1.96520832956077098242E2,  5.26445194995477358631E2,
                             9.34528527171957607540E2,   1.02755188689515710272E3,  5.57535335369399327526E2};
constexpr double ndtr_Q[] = {1.32281951154744992508E1, 8.67072140885989742329E1, 3.54937778887819891062E2,
                             9.75708501743205489753E2, 1.82390916687909736289E3, 2.24633760818710981792E3,
                             1.65666309194161350182E3, 5.57535340817727675546E2};
constexpr double ndtr_R[] = {5.64189583547755073984E-1, 1.27536670759978104416E0, 5.01905042251180477414E0,
                             6.16021097993053585195E0,  7.40974269950448939160E0, 2.97886665372100240670E0};
constexpr double ndtr_S[] = {2.26052863220117276590E0, 9.39603524938001434673E0, 1.20489539808096656605E1,
                             1.70814450747565897222E1, 9.60896809063285878198E0, 3.36907645100081516050E0};
constexpr double ndtr_T[] = {9.60497373987051638749E0, 9.00260197203842689217E1, 2.23200534594684319226E3,
                             7.00332514112805075473E3, 5.55923013010394962768E4};
constexpr double ndtr_U[] = {3.35617141647503099647E1, 5.21357949780152679795E2, 4.59432382970980127987E3,
                             2.26290000613890934246E4, 4.92673942608635921086E4};

double cephes_erf(double x);

double cephes_erfc(double a) {
    double p, q, x, y, z;

    if (std::isnan(a)) return NaN;
    if (a < 0.0) {
        x = -a;
    } else {
        x = a;
    }
    if (x < 1.0) return 1.0 - cephes_erf(a);

    z = -a * a;
    if (z < -MAXLOG) goto under;
    z = std::exp(z);
    if (x < 8.0) {
        p = polevl(x, ndtr_P, 8);
        q = p1evl(x, ndtr_Q, 8);
    } else {
        p = polevl(x, ndtr_R, 5);
        q = p1evl(x, ndtr_S, 6);
    }
    y = (z * p) / q;
    if (a < 0) y = 2.0 - y;
    if (y != 0.0) return y;

under:
    if (a < 0) return 2.0;
    return 0.0;
}

double cephes_erf(double x) {
    double y, z;
    if (std::isnan(x)) return NaN;
    if (x < 0.0) return -cephes_erf(-x);
    if (std::abs(x) > 1.0) return 1.0 - cephes_erfc(x);
    z = x * x;
    y = x * polevl(z, ndtr_T, 4) / p1evl(z, ndtr_U, 5);
    return y;
}

// --- igam_asymp_coeff.h -----------------------------------------------------

constexpr int igam_asymp_coeff_K = 25;
constexpr int igam_asymp_coeff_N = 25;

// clang-format off
constexpr double igam_asymp_coeff_d[igam_asymp_coeff_K][igam_asymp_coeff_N] = {
    {-3.3333333333333333e-1,  8.3333333333333333e-2,   -1.4814814814814815e-2,  1.1574074074074074e-3,
     3.527336860670194e-4,    -1.7875514403292181e-4,  3.9192631785224378e-5,   -2.1854485106799922e-6,
     -1.85406221071516e-6,    8.296711340953086e-7,    -1.7665952736826079e-7,  6.7078535434014986e-9,
     1.0261809784240308e-8,   -4.3820360184533532e-9,  9.1476995822367902e-10,  -2.551419399494625e-11,
     -5.8307721325504251e-11, 2.4361948020667416e-11,  -5.0276692801141756e-12, 1.1004392031956135e-13,
     3.3717632624009854e-13,  -1.3923887224181621e-13, 2.8534893807047443e-14,  -5.1391118342425726e-16,
     -1.9752288294349443e-15},
    {-1.8518518518518519e-3,  -3.4722222222222222e-3,  2.6455026455026455e-3,   -9.9022633744855967e-4,
     2.0576131687242798e-4,   -4.0187757201646091e-7,  -1.8098550334489978e-5,  7.6491609160811101e-6,
     -1.6120900894563446e-6,  4.6471278028074343e-9,   1.378633446915721e-7,    -5.752545603517705e-8,
     1.1951628599778147e-8,   -1.7543241719747648e-11, -1.0091543710600413e-9,  4.1627929918425826e-10,
     -8.5639070264929806e-11, 6.0672151016047586e-14,  7.1624989648114854e-12,  -2.9331866437714371e-12,
     5.9966963656836887e-13,  -2.1671786527323314e-16, -4.9783399723692616e-14, 2.0291628823713425e-14,
     -4.13125571381061e-15},
    {4.1335978835978836e-3,   -2.6813271604938272e-3,  7.7160493827160494e-4,  2.0093878600823045e-6,
     -1.0736653226365161e-4,  5.2923448829120125e-5,   -1.2760635188618728e-5, 3.4235787340961381e-8,
     1.3721957309062933e-6,   -6.298992138380055e-7,   1.4280614206064242e-7,  -2.0477098421990866e-10,
     -1.4092529910867521e-8,  6.228974084922022e-9,    -1.3670488396617113e-9, 9.4283561590146782e-13,
     1.2872252400089318e-10,  -5.5645956134363321e-11, 1.1975935546366981e-11, -4.1689782251838635e-15,
     -1.0940640427884594e-12, 4.6622399463901357e-13,  -9.905105763906906e-14, 1.8931876768373515e-17,
     8.8592218725911273e-15},
    {6.4943415637860082e-4,   2.2947209362139918e-4,   -4.6918949439525571e-4,  2.6772063206283885e-4,
     -7.5618016718839764e-5,  -2.3965051138672967e-7,  1.1082654115347302e-5,   -5.6749528269915966e-6,
     1.4230900732435884e-6,   -2.7861080291528142e-11, -1.6958404091930277e-7,  8.0994649053880824e-8,
     -1.9111168485973654e-8,  2.3928620439808118e-12,  2.0620131815488798e-9,   -9.4604966618551322e-10,
     2.1541049775774908e-10,  -1.388823336813903e-14,  -2.1894761681963939e-11, 9.7909989511716851e-12,
     -2.1782191880180962e-12, 6.2088195734079014e-17,  2.126978363279737e-13,   -9.3446887915174333e-14,
     2.0453671226782849e-14},
    {-8.618882909167117e-4,   7.8403922172006663e-4,   -2.9907248030319018e-4, -1.4638452578843418e-6,
     6.6414982154651222e-5,   -3.9683650471794347e-5,  1.1375726970678419e-5,  2.5074972262375328e-10,
     -1.6954149536558306e-6,  8.9075075322053097e-7,   -2.2929348340008049e-7, 2.956794137544049e-11,
     2.8865829742708784e-8,   -1.4189739437803219e-8,  3.4463580499464897e-9,  -2.3024517174528067e-13,
     -3.9409233028046405e-10, 1.8602338968504502e-10,  -4.356323005056618e-11, 1.2786001016296231e-15,
     4.6792750266579195e-12,  -2.1492464706134829e-12, 4.9088156148096522e-13, -6.3385914848915603e-18,
     -5.0453320690800944e-14},
    {-3.3679855336635815e-4,  -6.9728137583658578e-5,  2.7727532449593921e-4,  -1.9932570516188848e-4,
     6.7977804779372078e-5,   1.419062920643967e-7,    -1.3594048189768693e-5, 8.0184702563342015e-6,
     -2.2914811765080952e-6,  -3.252473551298454e-10,  3.4652846491085265e-7,  -1.8447187191171343e-7,
     4.8240967037894181e-8,   -1.7989466721743515e-14, -6.3061945000135234e-9, 3.1624176287745679e-9,
     -7.8409242536974293e-10, 5.1926791652540407e-15,  9.3589442423067836e-11, -4.5134262161632782e-11,
     1.0799129993116827e-11,  -3.661886712685252e-17,  -1.210902069055155e-12, 5.6807435849905643e-13,
     -1.3249659916340829e-13},
    {5.3130793646399222e-4,   -5.9216643735369388e-4,  2.7087820967180448e-4,   7.9023532326603279e-7,
     -8.1539693675619688e-5,  5.6116827531062497e-5,   -1.8329116582843376e-5,  -3.0796134506033048e-9,
     3.4651553688036091e-6,   -2.0291327396058604e-6,  5.7887928631490037e-7,   2.338630673826657e-13,
     -8.8286007463304835e-8,  4.7435958880408128e-8,   -1.2545415020710382e-8,  8.6496488580102925e-14,
     1.6846058979264063e-9,   -8.5754928235775947e-10, 2.1598224929232125e-10,  -7.6132305204761539e-16,
     -2.6639822008536144e-11, 1.3065700536611057e-11,  -3.1799163902367977e-12, 4.7109761213674315e-18,
     3.6902800842763467e-13},
    {3.4436760689237767e-4,   5.1717909082605922e-5,   -3.3493161081142236e-4,  2.812695154763237e-4,
     -1.0976582244684731e-4,  -1.2741009095484485e-7,  2.7744451511563644e-5,   -1.8263488805711333e-5,
     5.7876949497350524e-6,   4.9387589339362704e-10,  -1.0595367014026043e-6,  6.1667143761104075e-7,
     -1.7562973359060462e-7,  -1.2974473287015439e-12, 2.695423606288966e-8,    -1.4578352908731271e-8,
     3.887645959386175e-9,    -3.8810022510194121e-17, -5.3279941738772867e-10, 2.7437977643314845e-10,
     -6.9957960920705679e-11, 2.5899863874868481e-17,  8.8566890996696381e-12,  -4.403168815871311e-12,
     1.0865561947091654e-12},
    {-6.5262391859530942e-4, 8.3949872067208728e-4,   -4.3829709854172101e-4, -6.969091458420552e-7,
     1.6644846642067548e-4,  -1.2783517679769219e-4,  4.6299532636913043e-5,  4.5579098679227077e-9,
     -1.0595271125805195e-5, 6.7833429048651666e-6,   -2.1075476666258804e-6, -1.7213731432817145e-11,
     3.7735877416110979e-7,  -2.1867506700122867e-7,  6.2202288040189269e-8,  6.5977038267330006e-16,
     -9.5903864974256858e-9, 5.2132144922808078e-9,   -1.3991589583935709e-9, 5.382058999060575e-16,
     1.9484714275467745e-10, -1.0127287556389682e-10, 2.6077347197254926e-11, -5.0904186999932993e-18,
     -3.3721464474854592e-12},
    {-5.9676129019274625e-4, -7.2048954160200106e-5,  6.7823088376673284e-4,   -6.4014752602627585e-4,
     2.7750107634328704e-4,  1.8197008380465151e-7,   -8.4795071170685032e-5,  6.105192082501531e-5,
     -2.1073920183404862e-5, -8.8585890141255994e-10, 4.5284535953805377e-6,   -2.8427815022504408e-6,
     8.7082341778646412e-7,  3.6886101871706965e-12,  -1.5344695190702061e-7,  8.862466778790695e-8,
     -2.5184812301826817e-8, -1.0225912098215092e-14, 3.8969470758154777e-9,   -2.1267304792235635e-9,
     5.7370135528051385e-10, -1.887749850169741e-19,  -8.0931538694657866e-11, 4.2382723283449199e-11,
     -1.1002224534207726e-11},
    {1.3324454494800656e-3,  -1.9144384985654775e-3, 1.1089369134596637e-3,   9.932404122642299e-7,
     -5.0874501293093199e-4, 4.2735056665392884e-4,  -1.6858853767910799e-4,  -8.1301893922784998e-9,
     4.5284402370562147e-5,  -3.127053674781734e-5,  1.044986828530338e-5,    4.8435226265680926e-11,
     -2.1482565873456258e-6, 1.329369701097492e-6,   -4.0295693092101029e-7,  -1.7567877666323291e-13,
     7.0145043163668257e-8,  -4.040787734999483e-8,  1.1474026743371963e-8,   3.9642746853563325e-18,
     -1.7804938269892714e-9, 9.7480262548731646e-10, -2.6405338676507616e-10, 5.794875163403742e-18,
     3.7647749553543836e-11},
    {1.579727660730835e-3,   1.6251626278391582e-4,   -2.0633421035543276e-3, 2.1389686185689098e-3,
     -1.0108559391263003e-3, -3.9912705529919201e-7,  3.6235025084764691e-4,  -2.8143901463712154e-4,
     1.0449513336495887e-4,  2.1211418491830297e-9,   -2.5779417251947842e-5, 1.7281818956040463e-5,
     -5.6413773872904282e-6, -1.1024320105776174e-11, 1.1223224418895175e-6,  -6.8693396379526735e-7,
     2.0653236975414887e-7,  4.6714772409838506e-14,  -3.5609886164949055e-8, 2.0470855345905963e-8,
     -5.8091738633283358e-9, -1.332821287582869e-16,  9.0354604391335133e-10, -4.9598782517330834e-10,
     1.3481607129399749e-10},
    {-4.0725121195140166e-3, 6.4033628338080698e-3,  -4.0410161081676618e-3, -2.183732802866233e-6,
     2.1740441801254639e-3,  -1.9700440518418892e-3, 8.3595469747962458e-4,  1.9445447567109655e-8,
     -2.5779387120421696e-4, 1.9009987368139304e-4,  -6.7696499937438965e-5, -1.4440629666426572e-10,
     1.5712512518742269e-5,  -1.0304008744776893e-5, 3.304517767401387e-6,   7.9829760242325709e-13,
     -6.4097794149313004e-7, 3.8894624761300056e-7,  -1.1618347644948869e-7, -2.816808630596451e-15,
     1.9878012911297093e-8,  -1.1407719956357511e-8, 3.2355857064185555e-9,  4.1759468293455945e-20,
     -5.0423112718105824e-10},
    {-5.9475779383993003e-3, -5.4016476789260452e-4,  8.7910413550767898e-3,  -9.8576315587856125e-3,
     5.0134695031021538e-3,  1.2807521786221875e-6,   -2.0626019342754683e-3, 1.7109128573523058e-3,
     -6.7695312714133799e-4, -6.9011545676562133e-9,  1.8855128143995902e-4,  -1.3395215663491969e-4,
     4.6263183033528039e-5,  4.0034230613321351e-11,  -1.0255652921494033e-5, 6.612086372797651e-6,
     -2.0913022027253008e-6, -2.0951775649603837e-13, 3.9756029041993247e-7,  -2.3956211978815887e-7,
     7.1182883382145864e-8,  8.925574873053455e-16,   -1.2101547235064676e-8, 6.9350618248334386e-9,
     -1.9661464453856102e-9},
    {1.7402027787522711e-2,  -2.9527880945699121e-2, 2.0045875571402799e-2,  7.0289515966903407e-6,
     -1.2375421071343148e-2, 1.1976293444235254e-2,  -5.4156038466518525e-3, -6.3290893396418616e-8,
     1.8855118129005065e-3,  -1.473473274825001e-3,  5.5515810097708387e-4,  5.2406834412550662e-10,
     -1.4357913535784836e-4, 9.9181293224943297e-5,  -3.3460834749478311e-5, -3.5755837291098993e-12,
     7.1560851960630076e-6,  -4.5516802628155526e-6, 1.4236576649271475e-6,  1.8803149082089664e-14,
     -2.6623403898929211e-7, 1.5950642189595716e-7,  -4.7187514673841102e-8, -6.5107872958755177e-17,
     7.9795091026746235e-9},
    {3.0249124160905891e-2,  2.4817436002649977e-3,  -4.9939134373457022e-2, 5.9915643009307869e-2,
     -3.2483207601623391e-2, -5.7212968652103441e-6, 1.5085251778569354e-2,  -1.3261324005088445e-2,
     5.5515262632426148e-3,  3.0263182257030016e-8,  -1.7229548406756723e-3, 1.2893570099929637e-3,
     -4.6845138348319876e-4, -1.830259937893045e-10, 1.1449739014822654e-4,  -7.7378565221244477e-5,
     2.5625836246985201e-5,  1.0766165333192814e-12, -5.3246809282422621e-6, 3.349634863064464e-6,
     -1.0381253128684018e-6, -5.608909920621128e-15, 1.9150821930676591e-7,  -1.1418365800203486e-7,
     3.3654425209171788e-8},
    {-9.9051020880159045e-2, 1.7954011706123486e-1,  -1.2989606383463778e-1, -3.1478872752284357e-5,
     9.0510635276848131e-2,  -9.2828824411184397e-2, 4.4412112839877808e-2,  2.7779236316835888e-7,
     -1.7229543805449697e-2, 1.4182925050891573e-2,  -5.6214161633747336e-3, -2.39598509186381e-9,
     1.6029634366079908e-3,  -1.1606784674435773e-3, 4.1001337768153873e-4,  1.8365800754090661e-11,
     -9.5844256563655903e-5, 6.3643062337764708e-5,  -2.076250624489065e-5,  -1.1806020912804483e-13,
     4.2131808239120649e-6,  -2.6262241337012467e-6, 8.0770620494930662e-7,  6.0125912123632725e-16,
     -1.4729737374018841e-7},
    {-1.9994542198219728e-1, -1.5056113040026424e-2,  3.6470239469348489e-1,  -4.6435192311733545e-1,
     2.6640934719197893e-1,  3.4038266027147191e-5,   -1.3784338709329624e-1, 1.276467178337056e-1,
     -5.6213828755200985e-2, -1.753150885483011e-7,   1.9235592956768113e-2,  -1.5088821281095315e-2,
     5.7401854451350123e-3,  1.0622382710310225e-9,   -1.5335082692563998e-3, 1.0819320643228214e-3,
     -3.7372510193945659e-4, -6.6170909729031985e-12, 8.4263617380909628e-5,  -5.5150706827483479e-5,
     1.7769536448348069e-5,  3.8827923210205533e-14,  -3.53513697488768e-6,   2.1865832130045269e-6,
     -6.6812849447625594e-7},
    {7.2438608504029431e-1,  -1.3918010932653375,    1.0654143352413968,     1.876173868950258e-4,
     -8.2705501176152696e-1, 8.9352433347828414e-1,  -4.4971003995291339e-1, -1.6107401567546652e-6,
     1.9235590165271091e-1,  -1.6597702160042609e-1, 6.8882222681814333e-2,  1.3910091724608687e-8,
     -2.146911561508663e-2,  1.6228980898865892e-2,  -5.9796016172584256e-3, -1.1287469112826745e-10,
     1.5167451119784857e-3,  -1.0478634293553899e-3, 3.5539072889126421e-4,  8.1704322111801517e-13,
     -7.7773013442452395e-5, 5.0291413897007722e-5,  -1.6035083867000518e-5, 1.2469354315487605e-14,
     3.1369106244517615e-6},
    {1.6668949727276811,     1.165462765994632e-1,   -3.3288393225018906,    4.4692325482864037,
     -2.6977693045875807,    -2.600667859891061e-4,  1.5389017615694539,     -1.4937962361134612,
     6.8881964633233148e-1,  1.3077482004552385e-6,  -2.5762963325596288e-1, 2.1097676102125449e-1,
     -8.3714408359219882e-2, -7.7920428881354753e-9, 2.4267923064833599e-2,  -1.7813678334552311e-2,
     6.3970330388900056e-3,  4.9430807090480523e-11, -1.5554602758465635e-3, 1.0561196919903214e-3,
     -3.5277184460472902e-4, 9.3002334645022459e-14, 7.5285855026557172e-5,  -4.8186515569156351e-5,
     1.5227271505597605e-5},
    {-6.6188298861372935,    1.3397985455142589e+1,  -1.0789350606845146e+1, -1.4352254537875018e-3,
     9.2333694596189809,     -1.0456552819547769e+1, 5.5105526029033471,     1.2024439690716742e-5,
     -2.5762961164755816,    2.3207442745387179,     -1.0045728797216284,    -1.0207833290021914e-7,
     3.3975092171169466e-1,  -2.6720517450757468e-1, 1.0235252851562706e-1,  8.4329730484871625e-10,
     -2.7998284958442595e-2, 2.0066274144976813e-2,  -7.0554368915086242e-3, 1.9402238183698188e-12,
     1.6562888105449611e-3,  -1.1082898580743683e-3, 3.654545161310169e-4,   -5.1290032026971794e-11,
     -7.6340103696869031e-5},
    {-1.7112706061976095e+1, -1.1208044642899116,     3.7131966511885444e+1,  -5.2298271025348962e+1,
     3.3058589696624618e+1,  2.4791298976200222e-3,   -2.061089403411526e+1,  2.088672775145582e+1,
     -1.0045703956517752e+1, -1.2238783449063012e-5,  4.0770134274221141,     -3.473667358470195,
     1.4329352617312006,     7.1359914411879712e-8,   -4.4797257159115612e-1, 3.4112666080644461e-1,
     -1.2699786326594923e-1, -2.8953677269081528e-10, 3.3125776278259863e-2,  -2.3274087021036101e-2,
     8.0399993503648882e-3,  -1.177805216235265e-9,   -1.8321624891071668e-3, 1.2108282933588665e-3,
     -3.9479941246822517e-4},
    {7.389033153567425e+1,   -1.5680141270402273e+2, 1.322177542759164e+2,   1.3692876877324546e-2,
     -1.2366496885920151e+2, 1.4620689391062729e+2,  -8.0365587724865346e+1, -1.1259851148881298e-4,
     4.0770132196179938e+1,  -3.8210340013273034e+1, 1.719522294277362e+1,   9.3519707955168356e-7,
     -6.2716159907747034,    5.1168999071852637,     -2.0319658112299095,    -4.9507215582761543e-9,
     5.9626397294332597e-1,  -4.4220765337238094e-1, 1.6079998700166273e-1,  -2.4733786203223402e-8,
     -4.0307574759979762e-2, 2.7849050747097869e-2,  -9.4751858992054221e-3, 6.419922235909132e-6,
     2.1250180774699461e-3},
    {2.1216837098382522e+2,  1.3107863022633868e+1,  -4.9698285932871748e+2, 7.3121595266969204e+2,
     -4.8213821720890847e+2, -2.8817248692894889e-2, 3.2616720302947102e+2,  -3.4389340280087117e+2,
     1.7195193870816232e+2,  1.4038077378096158e-4,  -7.52594195897599e+1,   6.651969984520934e+1,
     -2.8447519748152462e+1, -7.613702615875391e-7,  9.5402237105304373,     -7.5175301113311376,
     2.8943997568871961,     -4.6612194999538201e-7, -8.0615149598794088e-1, 5.8483006570631029e-1,
     -2.0845408972964956e-1, 1.4765818959305817e-4,  5.1000433863753019e-2,  -3.3066252141883665e-2,
     1.5109265210467774e-2},
    {-9.8959643098322368e+2, 2.1925555360905233e+3,  -1.9283586782723356e+3, -1.5925738122215253e-1,
     1.9569985945919857e+3,  -2.4072514765081556e+3, 1.3756149959336496e+3,  1.2920735237496668e-3,
     -7.525941715948055e+2,  7.3171668742208716e+2,  -3.4137023466220065e+2, -9.9857390260608043e-6,
     1.3356313181291573e+2,  -1.1276295161252794e+2, 4.6310396098204458e+1,  -7.9237387133614756e-6,
     -1.4510726927018646e+1, 1.1111771248100563e+1,  -4.1690817945270892,    3.1008219800117808e-3,
     1.1220095449981468,     -7.6052379926149916e-1, 3.6262236505085254e-1,  2.216867741940747e-1,
     4.8683443692930507e-1}
};
// clang-format on

// --- igam.h -----------------------------------------------------------------

constexpr int igam_MAXITER = 2000;
constexpr int IGAM = 1;
constexpr int IGAMC = 0;
constexpr double igam_SMALL = 20;
constexpr double igam_LARGE = 200;
constexpr double igam_SMALLRATIO = 0.3;
constexpr double igam_LARGERATIO = 4.5;
constexpr double igam_big = 4.503599627370496e15;
constexpr double igam_biginv = 2.22044604925031308085e-16;

double igam_fac(double a, double x) {
    double ax, fac, res, num;

    if (std::abs(a - x) > 0.4 * std::abs(a)) {
        ax = a * std::log(x) - x - lgam_(a);
        if (ax < -MAXLOG) return 0.0;
        return std::exp(ax);
    }

    fac = a + lanczos_g - 0.5;
    res = std::sqrt(fac / std::exp(1)) / lanczos_sum_expg_scaled(a);

    if ((a < 200) && (x < 200)) {
        res *= std::exp(a - x) * std::pow(x / fac, a);
    } else {
        num = x - a - lanczos_g + 0.5;
        res *= std::exp(a * log1pmx(num / fac) + x * (0.5 - lanczos_g) / fac);
    }
    return res;
}

double igamc_continued_fraction(double a, double x) {
    int i;
    double ans, ax, c, yc, r, t, y, z;
    double pk, pkm1, pkm2, qk, qkm1, qkm2;

    ax = igam_fac(a, x);
    if (ax == 0.0) return 0.0;

    y = 1.0 - a;
    z = x + y + 1.0;
    c = 0.0;
    pkm2 = 1.0;
    qkm2 = x;
    pkm1 = x + 1.0;
    qkm1 = z * x;
    ans = pkm1 / qkm1;

    for (i = 0; i < igam_MAXITER; i++) {
        c += 1.0;
        y += 1.0;
        z += 2.0;
        yc = y * c;
        pk = pkm1 * z - pkm2 * yc;
        qk = qkm1 * z - qkm2 * yc;
        if (qk != 0) {
            r = pk / qk;
            t = std::abs((ans - r) / r);
            ans = r;
        } else {
            t = 1.0;
        }
        pkm2 = pkm1;
        pkm1 = pk;
        qkm2 = qkm1;
        qkm1 = qk;
        if (std::abs(pk) > igam_big) {
            pkm2 *= igam_biginv;
            pkm1 *= igam_biginv;
            qkm2 *= igam_biginv;
            qkm1 *= igam_biginv;
        }
        if (t <= MACHEP) break;
    }
    return ans * ax;
}

double igam_series(double a, double x) {
    int i;
    double ans, ax, c, r;

    ax = igam_fac(a, x);
    if (ax == 0.0) return 0.0;

    r = a;
    c = 1.0;
    ans = 1.0;
    for (i = 0; i < igam_MAXITER; i++) {
        r += 1.0;
        c *= x / r;
        ans += c;
        if (c <= MACHEP * ans) break;
    }
    return ans * ax / a;
}

double igamc_series(double a, double x) {
    int n;
    double fac = 1;
    double sum = 0;
    double term, logx;

    for (n = 1; n < igam_MAXITER; n++) {
        fac *= -x / n;
        term = fac / (a + n);
        sum += term;
        if (std::abs(term) <= MACHEP * std::abs(sum)) break;
    }
    logx = std::log(x);
    term = -cephes_expm1(a * logx - lgam1p(a));
    return term - std::exp(a * logx - lgam_(a)) * sum;
}

double asymptotic_series(double a, double x, int func) {
    int k, n, sgn;
    int maxpow = 0;
    double lambda = x / a;
    double sigma = (x - a) / a;
    double eta, res, ck, ckterm, term, absterm;
    double absoldterm = INF;
    double etapow[igam_asymp_coeff_N] = {1};
    double sum = 0;
    double afac = 1;

    if (func == IGAM) {
        sgn = -1;
    } else {
        sgn = 1;
    }

    if (lambda > 1) {
        eta = std::sqrt(-2 * log1pmx(sigma));
    } else if (lambda < 1) {
        eta = -std::sqrt(-2 * log1pmx(sigma));
    } else {
        eta = 0;
    }
    res = 0.5 * cephes_erfc(sgn * eta * std::sqrt(a / 2));

    for (k = 0; k < igam_asymp_coeff_K; k++) {
        ck = igam_asymp_coeff_d[k][0];
        for (n = 1; n < igam_asymp_coeff_N; n++) {
            if (n > maxpow) {
                etapow[n] = eta * etapow[n - 1];
                maxpow += 1;
            }
            ckterm = igam_asymp_coeff_d[k][n] * etapow[n];
            ck += ckterm;
            if (std::abs(ckterm) < MACHEP * std::abs(ck)) break;
        }
        term = ck * afac;
        absterm = std::abs(term);
        if (absterm > absoldterm) break;
        sum += term;
        if (absterm < MACHEP * std::abs(sum)) break;
        absoldterm = absterm;
        afac /= a;
    }
    res += sgn * std::exp(-0.5 * a * eta * eta) * sum / std::sqrt(2 * XSF_PI * a);
    return res;
}

double igamc(double a, double x);

double igam(double a, double x) {
    double absxma_a;

    if (std::isnan(a) || std::isnan(x)) return NaN;
    if (x < 0 || a < 0) {
        return NaN;
    } else if (a == 0) {
        if (x > 0) return 1;
        return NaN;
    } else if (x == 0) {
        return 0;
    } else if (std::isinf(a)) {
        if (std::isinf(x)) return NaN;
        return 0;
    } else if (std::isinf(x)) {
        return 1;
    }

    absxma_a = std::abs(x - a) / a;
    if ((a > igam_SMALL) && (a < igam_LARGE) && (absxma_a < igam_SMALLRATIO)) {
        return asymptotic_series(a, x, IGAM);
    } else if ((a > igam_LARGE) && (absxma_a < igam_LARGERATIO / std::sqrt(a))) {
        return asymptotic_series(a, x, IGAM);
    }

    if ((x > 1.0) && (x > a)) return (1.0 - igamc(a, x));
    return igam_series(a, x);
}

double igamc(double a, double x) {
    double absxma_a;

    if (std::isnan(a) || std::isnan(x)) return NaN;
    if (x < 0 || a < 0) {
        return NaN;
    } else if (a == 0) {
        if (x > 0) return 0;
        return NaN;
    } else if (x == 0) {
        return 1;
    } else if (std::isinf(a)) {
        if (std::isinf(x)) return NaN;
        return 1;
    } else if (std::isinf(x)) {
        return 0;
    }

    absxma_a = std::abs(x - a) / a;
    if ((a > igam_SMALL) && (a < igam_LARGE) && (absxma_a < igam_SMALLRATIO)) {
        return asymptotic_series(a, x, IGAMC);
    } else if ((a > igam_LARGE) && (absxma_a < igam_LARGERATIO / std::sqrt(a))) {
        return asymptotic_series(a, x, IGAMC);
    }

    if (x > 1.1) {
        if (x < a) return 1.0 - igam_series(a, x);
        return igamc_continued_fraction(a, x);
    } else if (x <= 0.5) {
        if (-0.4 / std::log(x) < a) return 1.0 - igam_series(a, x);
        return igamc_series(a, x);
    } else {
        if (x * 1.1 < a) return 1.0 - igam_series(a, x);
        return igamc_series(a, x);
    }
}

// --- igami.h ----------------------------------------------------------------

double find_inverse_s(double p, double q) {
    double s, t;
    constexpr double a[4] = {0.213623493715853, 4.28342155967104, 11.6616720288968, 3.31125922108741};
    constexpr double b[5] = {0.3611708101884203e-1, 1.27364489782223, 6.40691597760039, 6.61053765625462, 1};

    if (p < 0.5) {
        t = std::sqrt(-2 * std::log(p));
    } else {
        t = std::sqrt(-2 * std::log(q));
    }
    s = t - polevl(t, a, 3) / polevl(t, b, 4);
    if (p < 0.5) s = -s;
    return s;
}

double didonato_SN(double a, double x, unsigned N, double tolerance) {
    double sum = 1.0;
    if (N >= 1) {
        unsigned i;
        double partial = x / (a + 1);
        sum += partial;
        for (i = 2; i <= N; ++i) {
            partial *= x / (a + i);
            sum += partial;
            if (partial < tolerance) break;
        }
    }
    return sum;
}

// DiDonato & Morris's Eq 25, shared by two branches of find_inverse_gamma
// (xsf writes it out twice; the arithmetic is identical).
double didonato_eq25(double a, double y) {
    double c1 = (a - 1) * std::log(y);
    double c1_2 = c1 * c1;
    double c1_3 = c1_2 * c1;
    double c1_4 = c1_2 * c1_2;
    double a_2 = a * a;
    double a_3 = a_2 * a;

    double c2 = (a - 1) * (1 + c1);
    double c3 = (a - 1) * (-(c1_2 / 2) + (a - 2) * c1 + (3 * a - 5) / 2);
    double c4 = (a - 1) * ((c1_3 / 3) - (3 * a - 5) * c1_2 / 2 + (a_2 - 6 * a + 7) * c1 + (11 * a_2 - 46 * a + 47) / 6);
    double c5 = (a - 1) * (-(c1_4 / 4) + (11 * a - 17) * c1_3 / 6 + (-3 * a_2 + 13 * a - 13) * c1_2 +
                           (2 * a_3 - 25 * a_2 + 72 * a - 61) * c1 / 2 + (25 * a_3 - 195 * a_2 + 477 * a - 379) / 12);

    double y_2 = y * y;
    double y_3 = y_2 * y;
    double y_4 = y_2 * y_2;
    return y + c1 + (c2 / y) + (c3 / y_2) + (c4 / y_3) + (c5 / y_4);
}

double find_inverse_gamma(double a, double p, double q) {
    double result;

    if (a == 1) {
        if (q > 0.9) {
            result = -std::log1p(-p);
        } else {
            result = -std::log(q);
        }
    } else if (a < 1) {
        double g = Gamma(a);
        double b = q * g;

        if ((b > 0.6) || ((b >= 0.45) && (a >= 0.3))) {
            double u;
            if ((b * q > 1e-8) && (q > 1e-5)) {
                u = std::pow(p * g * a, 1 / a);
            } else {
                u = std::exp((-q / a) - SCIPY_EULER);
            }
            result = u / (1 - (u / (a + 1)));
        } else if ((a < 0.3) && (b >= 0.35)) {
            double t = std::exp(-SCIPY_EULER - b);
            double u = t * std::exp(t);
            result = t * std::exp(u);
        } else if ((b > 0.15) || (a >= 0.3)) {
            double y = -std::log(b);
            double u = y - (1 - a) * std::log(y);
            result = y - (1 - a) * std::log(u) - std::log(1 + (1 - a) / (1 + u));
        } else if (b > 0.1) {
            double y = -std::log(b);
            double u = y - (1 - a) * std::log(y);
            result = y - (1 - a) * std::log(u) -
                     std::log((u * u + 2 * (3 - a) * u + (2 - a) * (3 - a)) / (u * u + (5 - a) * u + 2));
        } else {
            result = didonato_eq25(a, -std::log(b));
        }
    } else {
        double s = find_inverse_s(p, q);

        double s_2 = s * s;
        double s_3 = s_2 * s;
        double s_4 = s_2 * s_2;
        double s_5 = s_4 * s;
        double ra = std::sqrt(a);

        double w = a + s * ra + (s_2 - 1) / 3;
        w += (s_3 - 7 * s) / (36 * ra);
        w -= (3 * s_4 + 7 * s_2 - 16) / (810 * a);
        w += (9 * s_5 + 256 * s_3 - 433 * s) / (38880 * a * ra);

        if ((a >= 500) && (std::abs(1 - w / a) < 1e-6)) {
            result = w;
        } else if (p > 0.5) {
            if (w < 3 * a) {
                result = w;
            } else {
                double D = std::fmax(2, a * (a - 1));
                double lg = lgam_(a);
                double lb = std::log(q) + lg;
                if (lb < -D * 2.3) {
                    result = didonato_eq25(a, -lb);
                } else {
                    double u = -lb + (a - 1) * std::log(w) - std::log(1 + (1 - a) / (1 + w));
                    result = -lb + (a - 1) * std::log(u) - std::log(1 + (1 - a) / (1 + u));
                }
            }
        } else {
            double z = w;
            double ap1 = a + 1;
            double ap2 = a + 2;
            if (w < 0.15 * ap1) {
                double v = std::log(p) + lgam_(ap1);
                z = std::exp((v + w) / a);
                s = std::log1p(z / ap1 * (1 + z / ap2));
                z = std::exp((v + z - s) / a);
                s = std::log1p(z / ap1 * (1 + z / ap2));
                z = std::exp((v + z - s) / a);
                s = std::log1p(z / ap1 * (1 + z / ap2 * (1 + z / (a + 3))));
                z = std::exp((v + z - s) / a);
            }

            if ((z <= 0.01 * ap1) || (z > 0.7 * ap1)) {
                result = z;
            } else {
                double ls = std::log(didonato_SN(a, z, 100, 1e-4));
                double v = std::log(p) + lgam_(ap1);
                z = std::exp((v + z - ls) / a);
                result = z * (1 - (a * std::log(z) - z - v + ls) / (a - z));
            }
        }
    }
    return result;
}

double igamci(double a, double q);

double igami(double a, double p) {
    int i;
    double x, fac, f_fp, fpp_fp;

    if (std::isnan(a) || std::isnan(p)) {
        return NaN;
    } else if ((a < 0) || (p < 0) || (p > 1)) {
        // xsf records a domain error here and carries on (no return).
    } else if (p == 0.0) {
        return 0.0;
    } else if (p == 1.0) {
        return INF;
    } else if (p > 0.9) {
        return igamci(a, 1 - p);
    }

    x = find_inverse_gamma(a, p, 1 - p);
    for (i = 0; i < 3; i++) {
        fac = igam_fac(a, x);
        if (fac == 0.0) return x;
        f_fp = (igam(a, x) - p) * x / fac;
        fpp_fp = -1.0 + (a - 1) / x;
        if (std::isinf(fpp_fp)) {
            x = x - f_fp;
        } else {
            x = x - f_fp / (1.0 - 0.5 * f_fp * fpp_fp);
        }
    }
    return x;
}

double igamci(double a, double q) {
    int i;
    double x, fac, f_fp, fpp_fp;

    if (std::isnan(a) || std::isnan(q)) {
        return NaN;
    } else if ((a < 0.0) || (q < 0.0) || (q > 1.0)) {
        // xsf records a domain error here and carries on (no return).
    } else if (q == 0.0) {
        return INF;
    } else if (q == 1.0) {
        return 0.0;
    } else if (q > 0.9) {
        return igami(a, 1 - q);
    }

    x = find_inverse_gamma(a, 1 - q, q);
    for (i = 0; i < 3; i++) {
        fac = igam_fac(a, x);
        if (fac == 0.0) return x;
        f_fp = (igamc(a, x) - q) * x / (-fac);
        fpp_fp = -1.0 + (a - 1) / x;
        if (std::isinf(fpp_fp)) {
            x = x - f_fp;
        } else {
            x = x - f_fp / (1.0 - 0.5 * f_fp * fpp_fp);
        }
    }
    return x;
}

}  // namespace

double gammaincc(double a, double x) { return igamc(a, x); }

std::vector<double> gammaincc(double a, std::span<const double> x) {
    std::vector<double> out(x.size());
    for (std::size_t i = 0; i < x.size(); ++i) out[i] = igamc(a, x[i]);
    return out;
}

double gammainc(double a, double x) { return igam(a, x); }
double gammainccinv(double a, double q) { return igamci(a, q); }
double gammaincinv(double a, double p) { return igami(a, p); }
double lgam(double x) { return lgam_(x); }
double gamma(double x) { return Gamma(x); }
double erfc(double x) { return cephes_erfc(x); }
double zeta(double x, double q) { return zeta_(x, q); }

// --- ndtri.h (xsf::cephes::ndtri, which scipy.special.ndtri calls) ----------

namespace {

// approximation for 0 <= |y - 0.5| <= 3/8
constexpr double ndtri_P0[5] = {
    -5.99633501014107895267E1, 9.80010754185999661536E1,  -5.66762857469070293439E1,
    1.39312609387279679503E1,  -1.23916583867381258016E0,
};
constexpr double ndtri_Q0[8] = {
    /* 1.00000000000000000000E0, */
    1.95448858338141759834E0, 4.67627912898881538453E0,  8.63602421390890590575E1, -2.25462687854119370527E2,
    2.00260212380060660359E2, -8.20372256168333339912E1, 1.59056225126211695515E1, -1.18331621121330003142E0,
};
// z = sqrt(-2 log y) between 2 and 8, i.e. y between exp(-2) = .135 and
// exp(-32) = 1.27e-14
constexpr double ndtri_P1[9] = {
    4.05544892305962419923E0,   3.15251094599893866154E1,   5.71628192246421288162E1,
    4.40805073893200834700E1,   1.46849561928858024014E1,   2.18663306850790267539E0,
    -1.40256079171354495875E-1, -3.50424626827848203418E-2, -8.57456785154685413611E-4,
};
constexpr double ndtri_Q1[8] = {
    /*  1.00000000000000000000E0, */
    1.57799883256466749731E1,   4.53907635128879210584E1,   4.13172038254672030440E1,
    1.50425385692907503408E1,   2.50464946208309415979E0,   -1.42182922854787788574E-1,
    -3.80806407691578277194E-2, -9.33259480895457427372E-4,
};
// z between 8 and 64, i.e. y between exp(-32) = 1.27e-14 and exp(-2048) = 3.67e-890
constexpr double ndtri_P2[9] = {
    3.23774891776946035970E0,  6.91522889068984211695E0,  3.93881025292474443415E0,
    1.33303460815807542389E0,  2.01485389549179081538E-1, 1.23716634817820021358E-2,
    3.01581553508235416007E-4, 2.65806974686737550832E-6, 6.23974539184983293730E-9,
};
constexpr double ndtri_Q2[8] = {
    /*  1.00000000000000000000E0, */
    6.02427039364742014255E0,  3.67983563856160859403E0,  1.37702099489081330271E0,  2.16236993594496635890E-1,
    1.34204006088543189037E-2, 3.28014464682127739104E-4, 2.89247864745380683936E-6, 6.79019408009981274425E-9,
};

// --- CPython's Modules/mathmodule.c: m_lgamma and what it reaches ------------
//
// Copyright (c) 2001 Python Software Foundation; All Rights Reserved.
// Translated under the PSF License Agreement (version 2).

constexpr double PY_PI = 3.141592653589793238462643383279502884197;
constexpr double PY_LOGPI = 1.144729885849400174143427351353058711647;
constexpr int LANCZOS_N = 13;
constexpr double py_lanczos_g = 6.024680040776729583740234375;
constexpr double lanczos_num_coeffs[LANCZOS_N] = {
    23531376880.410759688572007674451636754734846804940,
    42919803642.649098768957899047001988850926355848959,
    35711959237.355668049440185451547166705960488635843,
    17921034426.037209699919755754458931112671403265390,
    6039542586.3520280050642916443072979210699388420708,
    1439720407.3117216736632230727949123939715485786772,
    248874557.86205415651146038641322942321632125127801,
    31426415.585400194380614231628318205362874684987640,
    2876370.6289353724412254090516208496135991145378768,
    186056.26539522349504029498971604569928220784236328,
    8071.6720023658162106380029022722506138218516325024,
    210.82427775157934587250973392071336271166969580291,
    2.5066282746310002701649081771338373386264310793408};
// denominator is x*(x+1)*...*(x+LANCZOS_N-2)
constexpr double lanczos_den_coeffs[LANCZOS_N] = {0.0,        39916800.0, 120543840.0, 150917976.0, 105258076.0,
                                                  45995730.0, 13339535.0, 2637558.0,   357423.0,    32670.0,
                                                  1925.0,     66.0,       1.0};

double py_sinpi(double x) {
    const double y = std::fmod(std::abs(x), 2.0);
    const int n = static_cast<int>(std::round(2.0 * y));   // C round (half away from zero), as CPython's
    double r = NaN;
    switch (n) {
        case 0: r = std::sin(PY_PI * y); break;
        case 1: r = std::cos(PY_PI * (y - 0.5)); break;
        // N.B. -sin(pi*(y-1.0)) is *not* equivalent: it would give -0.0
        // instead of 0.0 when y == 1.0.
        case 2: r = std::sin(PY_PI * (1.0 - y)); break;
        case 3: r = -std::cos(PY_PI * (y - 1.5)); break;
        case 4: r = std::sin(PY_PI * (y - 2.0)); break;
        default: break;
    }
    return std::copysign(1.0, x) * r;
}

// Lanczos' sum L_g(x), for positive x.
double lanczos_sum(double x) {
    double num = 0.0, den = 0.0;
    if (x < 5.0) {
        for (int i = LANCZOS_N; --i >= 0;) {
            num = num * x + lanczos_num_coeffs[i];
            den = den * x + lanczos_den_coeffs[i];
        }
    } else {
        for (int i = 0; i < LANCZOS_N; i++) {
            num = num / x + lanczos_num_coeffs[i];
            den = den / x + lanczos_den_coeffs[i];
        }
    }
    return num / den;
}

}  // namespace

double ndtri(double y0) {
    double x, y, z, y2, x0, x1;
    int code;

    if (y0 == 0.0) return -INF;
    if (y0 == 1.0) return INF;
    if (y0 < 0.0 || y0 > 1.0) return NaN;
    code = 1;
    y = y0;
    if (y > (1.0 - 0.13533528323661269189)) { /* 0.135... = exp(-2) */
        y = 1.0 - y;
        code = 0;
    }

    if (y > 0.13533528323661269189) {
        y = y - 0.5;
        y2 = y * y;
        x = y + y * (y2 * polevl(y2, ndtri_P0, 4) / p1evl(y2, ndtri_Q0, 8));
        x = x * SQRT2PI;
        return x;
    }

    x = std::sqrt(-2.0 * std::log(y));
    x0 = x - std::log(x) / x;

    z = 1.0 / x;
    if (x < 8.0) { /* y > exp(-32) = 1.2664165549e-14 */
        x1 = z * polevl(z, ndtri_P1, 8) / p1evl(z, ndtri_Q1, 8);
    } else {
        x1 = z * polevl(z, ndtri_P2, 8) / p1evl(z, ndtri_Q2, 8);
    }
    x = x0 - x1;
    if (code != 0) x = -x;
    return x;
}

double norm_isf(double q) {
    // rv_continuous.isf: 0 < q < 1 -> _isf(q) * scale + loc; q == 1 -> the
    // support's lower end, q == 0 its upper end; anything else badvalue.
    if (q > 0.0 && q < 1.0) return -ndtri(q) * 1.0 + 0.0;
    if (q == 1.0) return -INF;
    if (q == 0.0) return INF;
    return NaN;
}

double gamma_logsf(double x, double a) {
    // rv_continuous.logsf: the output starts at -inf; badvalue (NaN) where
    // the shape fails _argcheck (a > 0) or x is NaN; 0 where x <= the
    // support's lower end (0); _logsf inside the open support (0, inf).
    if (!(a > 0.0) || std::isnan(x)) return NaN;
    if (x <= 0.0) return 0.0;
    if (!(x < INF)) return -INF;
    // rv_continuous._logsf: apply_where(x > median, log(sf), log1p(-cdf))
    const double median = gammaincinv(a, 0.5);   // gamma_gen._ppf(0.5, a)
    if (x > median) return std::log(gammaincc(a, x));
    return std::log1p(-gammainc(a, x));
}

double py_lgamma(double x) {
    if (!std::isfinite(x)) {
        if (std::isnan(x)) return x;   // lgamma(nan) = nan
        return INF;                    // lgamma(+-inf) = +inf
    }
    // integer arguments
    if (x == std::floor(x) && x <= 2.0) {
        if (x <= 0.0) return INF;   // Python: ValueError (EDOM)
        return 0.0;                 // lgamma(1) = lgamma(2) = 0.0
    }
    const double absx = std::abs(x);
    // tiny arguments: lgamma(x) ~ -log(fabs(x)) for small x
    if (absx < 1e-20) return -std::log(absx);
    double r = std::log(lanczos_sum(absx)) - py_lanczos_g;
    r += (absx - 0.5) * (std::log(absx + py_lanczos_g - 0.5) - 1);
    if (x < 0.0) r = PY_LOGPI - std::log(std::abs(py_sinpi(absx))) - std::log(absx) - r;
    return r;
}

}  // namespace sstvae::math
